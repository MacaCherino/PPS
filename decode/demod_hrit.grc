options:
  parameters:
    author: Lucas Teske
    description: https://github.com/racerxdl/open-satellite-project
    generate_options: qt_gui
    id: demod_tcp_qt
    output_language: python
    title: HRIT Demodulator
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1694.1e6
  states: {}
- name: clock_alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: Clock Alpha
    min_len: '150'
    start: '1e-3'
    step: '1e-5'
    stop: '10e-3'
    value: '3.7e-3'
  states: {}
- name: file_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: pll_alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,1,1,1
    label: PLL Alpha
    min_len: '150'
    start: '0.00100'
    step: '0.00001'
    stop: '0.10000'
    value: '1.99e-3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symbol_rate*1.0)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 927e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.5'
    max_gain: '4000'
    rate: '100e-4'
    reference: '0.5'
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\macal\OneDrive\Documents\PPS\DSP\GNU Radio\python\files\test3\demod_slc.bin
    type: byte
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: file_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\macal\OneDrive\Documents\PPS\DSP\GNU Radio\2024-07-16_16-00-01_2400000SPS_1694600249Hz.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: clock_alpha
    gain_omega: clock_alpha**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: pll_alpha
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: symbol_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 300e3
    win: window.WIN_BLACKMAN
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: IQ Raw Record
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    axislabels: 'False'
    color1: '"dark green"'
    grid: 'True'
    gui_hint: 0,1,5,1
    legend: 'False'
    name: Output Constellation
    size: '1024'
    type: complex
    update_time: '0.01'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    axislabels: 'False'
    bw: samp_rate
    color1: '"dark red"'
    fc: center_freq
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,0,1,1
    legend: 'False'
    name: Input Signal
    showports: 'True'
    type: complex
    update_time: '0.01'
    ymax: '-40'
    ymin: '-60'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.3'
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 0,2,7,1
    label1: ' '
    max: '30'
    min: '0'
    name: SNR
    type: float
    unit1: dB
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    color1: '3'
    fc: center_freq
    fftsize: '8192'
    gui_hint: 1,0,6,1
    int_max: '-40'
    int_min: '-50'
    legend: 'False'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '5'
    taps: ''
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.3'
    decim: '1'
    gain: '1'
    ntaps: '361'
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc_xx_0, '0', high_pass_filter_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_throttle_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0_0, '1', blocks_float_to_complex_0_0, '1']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_real_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [high_pass_filter_0, '0', blocks_rms_xx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_agc_xx_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_rms_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
